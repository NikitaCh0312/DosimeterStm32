# IAR project Project.ewp, settings and files
configuration Project (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205RE ST STM32F205RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F205xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F2xx/Include; ../Drivers/CMSIS/Include; ..\RTOS_Library; ..\RTOS_Library\FreeRTOS\portable\IAR\ARM_CM3; ..\Components; ..\HighLvl; ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f205xE.icf
  ILINK.IlinkAdditionalLibs: ..\RTOS_Library\Debug\Exe\RTOS_Library.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    Project/List/: Project.map
  group Application/EWARM
    ./: startup_stm32f205xx.s
  group Application/User/Core
    ../Core/Src/: adc.c dma.c gpio.c main.c rtc.c spi.c stm32f2xx_hal_msp.c stm32f2xx_hal_timebase_tim.c stm32f2xx_it.c tim.c
  group Components
    ../Components/: BoardInit.c BoardInit.h
  group Components/Buttons
    ../Components/Buttons/: Buttons.c Buttons.h
  group Components/Ethernet
    ../Components/Ethernet/: EthernetInit.c EthernetInit.h HtmlPage.c HtmlPage.h
  group Components/Ethernet/Ethernet
    ../Components/Ethernet/Ethernet/: socket.c socket.h wizchip_conf.c wizchip_conf.h
  group Components/Ethernet/Ethernet/w5500
    ../Components/Ethernet/Ethernet/W5500/: w5500.c w5500.h
  group Components/Ethernet/Internet/DHCP
    ../Components/Ethernet/Internet/DHCP/: dhcp.c dhcp.h
  group Components/Ethernet/Internet/DNS
    ../Components/Ethernet/Internet/DNS/: dns.c dns.h
  group Components/Ethernet/Internet/HttpServer
    ../Components/Ethernet/Internet/httpServer/: httpParser.c httpParser.h httpServer.c httpServer.h httpUtil.c httpUtil.h
  group Components/LCD
    ../Components/LCD/: LCD.c LCD.h LCD_Init.c LCD_Init.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rtc.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_spi.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c
  group HighLvl/modules
    ../HighLvl/modules/: Configuration.cpp Configuration.h Logger.cpp Logger.h MemoryCardMap.cpp MemoryCardMap.h RFIDCard.cpp RFIDCard.h Startup.cpp Startup.h
  group HighLvl/modules/Json
    ../HighLvl/modules/Json/: JsonObject.cpp JsonObject.h JsonSerializer.cpp JsonSerializer.h
  group HighLvl/modules/Menu
    ../HighLvl/modules/Menu/: CompositeMenuNode.cpp CompositeMenuNode.h IMenuNode.h Menu.cpp Menu.h SimpleMenuNode.cpp SimpleMenuNode.h
  group HighLvl/RTOS
    ../HighLvl/RTOS/: RTOSManager.cpp RTOSManager.h Task.cpp Task.h Thread.cpp Thread.h
  group HighLvl/Tasks
    ../HighLvl/Tasks/: ButtonsTask.cpp ButtonsTask.h DebugTask.cpp DebugTask.h DisplayTask.cpp DisplayTask.h EthernetTask.cpp EthernetTask.h MainLogicTask.cpp MainLogicTask.h RFIDTask.cpp RFIDTask.h TasksTypes.h
