<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Project.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\RTOS_Library\RTOS_Library.ewp</path>
    </project>
    <batchBuild />
</workspace>
